# Keil uVision project BH-STM32.uvprojx, settings and files
target RTC实时时钟 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\FWlib\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../../User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
    ../../User/rtc/: bsp_calendar.c bsp_date.c bsp_rtc.c
    ../../User/usart/: bsp_usart.c
    ../../User/lcd/: bsp_ili9341_lcd.c bsp_xpt2046_lcd.c
    ../../User/font/: fonts.c
    ../../User/Key/: bsp_key.c
    ../../User/flash/: bsp_spi_flash.c
    ../../User/led/: bsp_led.c
    ../../User/common/: common.c
    ../../User/TimBase/: bsp_TiMbase.c
    ../../User/systick/: bsp_SysTick.c
    ../../User/TPad/: bsp_tpad.c
    ../../User/temp/: bsp_tempad.c bsp_ds18b20.c
    ../../User/fan/: fan.c
    ../../User/beep/: bsp_beep.c
  group DOC
    ../../Doc/: readme.txt
  group APP
    ../../User/layer/: temperature.c clock_stop.c clock_alert.c clock.c clock_zone_config.c library.c
  group ui
    ../../User/ui/: button.c
